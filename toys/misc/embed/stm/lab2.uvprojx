# Keil uVision project lab2.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lab2
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Drivers
    ./: hal_gpio_driver.c hal_gpio_driver.h
    ./drivers/src/SPI/drivers/: hal_spi_driver.c hal_spi_driver.h
  group userApp
    ./: stack_op.s main.c
software components: CMSIS:CORE 5.0.1, Device:Startup 2.6.0
